Commit message: push the touch haptic to repo

File: surrol/assets/CH4/CH4_waypoints.urdf (robot description, URDF)
Before this commit: robot ring, 3 links, 2 joints
Links:
- link baseLink: mass 0.5 -> 0.01
